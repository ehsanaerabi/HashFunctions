# Keil uVision project blinky_blank_pca10028.uvprojx, settings and files
target nrf51422_xxac (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51
  c misc: --c99 --asm
  c include: ..\..\..
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c
    ./RTE/_nrf51422_xxac/: KeccakF-1600-opt32.c KeccakSponge.c
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE 4.3.0, Board Support:bsp 11.0.0-2.alpha, Device:Startup 8.3.1, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha
